/* UTF-8 to display-font encoding helpers.
 * Copyright (C) 2026  esp32-weather-epd contributors
 */

#include "text_encoding.h"
#include "config.h"

#ifdef FONT_ENCODING_CP1253

struct UnicodeBytePair
{
  uint16_t unicode;
  uint8_t encoded;
};

static const UnicodeBytePair CP1253_MAP[] = {
  {0x20AC, 0x80}, {0x201A, 0x82}, {0x0192, 0x83}, {0x201E, 0x84},
  {0x2026, 0x85}, {0x2020, 0x86}, {0x2021, 0x87}, {0x2030, 0x89},
  {0x2039, 0x8B}, {0x2018, 0x91}, {0x2019, 0x92}, {0x201C, 0x93},
  {0x201D, 0x94}, {0x2022, 0x95}, {0x2013, 0x96}, {0x2014, 0x97},
  {0x2122, 0x99}, {0x203A, 0x9B}, {0x00A0, 0xA0}, {0x0385, 0xA1},
  {0x0386, 0xA2}, {0x00A3, 0xA3}, {0x00A4, 0xA4}, {0x00A5, 0xA5},
  {0x00A6, 0xA6}, {0x00A7, 0xA7}, {0x00A8, 0xA8}, {0x00A9, 0xA9},
  {0x00AB, 0xAB}, {0x00AC, 0xAC}, {0x00AD, 0xAD}, {0x00AE, 0xAE},
  {0x2015, 0xAF}, {0x00B0, 0xB0}, {0x00B1, 0xB1}, {0x00B2, 0xB2},
  {0x00B3, 0xB3}, {0x0384, 0xB4}, {0x00B5, 0xB5}, {0x00B6, 0xB6},
  {0x00B7, 0xB7}, {0x0388, 0xB8}, {0x0389, 0xB9}, {0x038A, 0xBA},
  {0x00BB, 0xBB}, {0x038C, 0xBC}, {0x00BD, 0xBD}, {0x038E, 0xBE},
  {0x038F, 0xBF}, {0x0390, 0xC0}, {0x0391, 0xC1}, {0x0392, 0xC2},
  {0x0393, 0xC3}, {0x0394, 0xC4}, {0x0395, 0xC5}, {0x0396, 0xC6},
  {0x0397, 0xC7}, {0x0398, 0xC8}, {0x0399, 0xC9}, {0x039A, 0xCA},
  {0x039B, 0xCB}, {0x039C, 0xCC}, {0x039D, 0xCD}, {0x039E, 0xCE},
  {0x039F, 0xCF}, {0x03A0, 0xD0}, {0x03A1, 0xD1}, {0x03A3, 0xD3},
  {0x03A4, 0xD4}, {0x03A5, 0xD5}, {0x03A6, 0xD6}, {0x03A7, 0xD7},
  {0x03A8, 0xD8}, {0x03A9, 0xD9}, {0x03AA, 0xDA}, {0x03AB, 0xDB},
  {0x03AC, 0xDC}, {0x03AD, 0xDD}, {0x03AE, 0xDE}, {0x03AF, 0xDF},
  {0x03B0, 0xE0}, {0x03B1, 0xE1}, {0x03B2, 0xE2}, {0x03B3, 0xE3},
  {0x03B4, 0xE4}, {0x03B5, 0xE5}, {0x03B6, 0xE6}, {0x03B7, 0xE7},
  {0x03B8, 0xE8}, {0x03B9, 0xE9}, {0x03BA, 0xEA}, {0x03BB, 0xEB},
  {0x03BC, 0xEC}, {0x03BD, 0xED}, {0x03BE, 0xEE}, {0x03BF, 0xEF},
  {0x03C0, 0xF0}, {0x03C1, 0xF1}, {0x03C2, 0xF2}, {0x03C3, 0xF3},
  {0x03C4, 0xF4}, {0x03C5, 0xF5}, {0x03C6, 0xF6}, {0x03C7, 0xF7},
  {0x03C8, 0xF8}, {0x03C9, 0xF9}, {0x03CA, 0xFA}, {0x03CB, 0xFB},
  {0x03CC, 0xFC}, {0x03CD, 0xFD}, {0x03CE, 0xFE}
};

static uint8_t unicodeToCp1253(uint16_t codepoint)
{
  if (codepoint < 0x80)
  {
    return static_cast<uint8_t>(codepoint);
  }
  for (const UnicodeBytePair &entry : CP1253_MAP)
  {
    if (entry.unicode == codepoint)
    {
      return entry.encoded;
    }
  }
  return '?';
}

String encodeDisplayText(const String &text)
{
  String encoded;
  encoded.reserve(text.length());
  const uint8_t *bytes = reinterpret_cast<const uint8_t *>(text.c_str());
  size_t i = 0;

  while (i < text.length())
  {
    uint16_t codepoint;
    uint8_t current = bytes[i];
    if (current < 0x80)
    {
      codepoint = current;
      ++i;
    }
    else if ((current & 0xE0) == 0xC0 && i + 1 < text.length() &&
             (bytes[i + 1] & 0xC0) == 0x80)
    {
      codepoint = ((current & 0x1F) << 6) | (bytes[i + 1] & 0x3F);
      i += 2;
    }
    else if ((current & 0xF0) == 0xE0 && i + 2 < text.length() &&
             (bytes[i + 1] & 0xC0) == 0x80 &&
             (bytes[i + 2] & 0xC0) == 0x80)
    {
      codepoint = ((current & 0x0F) << 12) |
                  ((bytes[i + 1] & 0x3F) << 6) |
                  (bytes[i + 2] & 0x3F);
      i += 3;
    }
    else
    {
      // Preserve already-encoded CP1253 bytes and malformed input.
      encoded += static_cast<char>(current);
      ++i;
      continue;
    }
    encoded += static_cast<char>(unicodeToCp1253(codepoint));
  }
  return encoded;
}

#else

String encodeDisplayText(const String &text)
{
  return text;
}

#endif
